# Keil uVision project YE5955-LORA.uvprojx, settings and files
target YE5955-LORA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL16Z64xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IROM(0x00000000,0x00010000) IRAM(0x1FFFF800,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: YE5955-LORA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL FREEDOM CMSIS FTFA
  c include: .\DRV;.\APP;.\STARTUP;.\CMSIS;.\STARTUP\headers;.\CMSIS\Include;.\Modbus;.\K60flash;.\W25Q128;.\DRV;.\lowpower;D:\YE5955-LORA-LM005A;.\mdl;.\mdl\rttviewer
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group APP
    ./APP/: includes.h main.c main.h app.h filter.c
  group LM005A
    ./: LM005A.c LM005A.h
  group Drv
    ./DRV/: MKL_adc.c MKL_gpio.c MKL_spi.c MKL_tpm.c MKL_uart.c MKL_pit.c MKL_lptmr.c MKL_LPO_RTC.c retarget_mdk.c mcg.c
  group STARTUP
    ./STARTUP/: arm_cm0.c system_MKL25Z4.c startup_MKL25Z4.s
    ./: system8M.c
  group MODBUS
    ./Modbus/: modbus.h ModBus.c
  group W25Q128
    ./W25Q128/: w25qxx.c w25qxx.h
  group FLASH
    ./K60flash/: flash.c flash.h
  group Lowpower
    ./lowpower/: powerswitch.c powerswitch.h
  group mdl/rtt
    ./mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
