/****************************************Copyright (c)****************************************************
**               Copyright � 2003~2009 Shenzhen uCdragon Technology Co.,Ltd. All Rights Reserved 
**
**                                 http://www.ucdragon.com
**
**      深圳市优龙科技有限公司所提供的所有服务内容旨在协助客户加速产品的研发进度，在服务过程中所提供
**  的任何程序、文档、测试结果、方案、支持等资料和信息，都仅供参考，客户有权不使用或自行参考修改，本公司不
**  提供任何的完整性、可靠性等保证，若在客户使用过程中因任何原因造成的特别的、偶然的或间接的损失，本公司不
**  承担任何责任。
**                                                                        —深圳市优龙科技有限公司
**
**--------------File Info---------------------------------------------------------------------------------
** File name:               MKL_spi.c
** Last modified date:     
** Last version:            V1.0
** Descriptions:            spi相关函数
**
** Modified date:      
** Version:            
** Descriptions:       
**
*********************************************************************************************************/
#include "includes.h"


/*********************************************************************************************************
** Function name:           spiInit
** Descriptions:            spi初始化
** input parameters:        SPI输入基地址 输入主从模式
** output parameters:       none
** Returned value:          none
** Created by:              
** Created date
**--------------------------------------------------------------------------------------------------------
** Modified by:             
** Modified date:           
*********************************************************************************************************/
void spiInit (SPI_MemMapPtr SPI,BOOLEAN bMode)
{
    SIM_SCGC4 |= SIM_SCGC4_SPI0_MASK;                                   /* 开启SPI0                     */
                                                                        /* CPOL = 0, SCK 为低有效       */
                                                                        /* MSTR = 1, SPI 处于主模式     */
                                                                        /* LSBF = 0, MSB (位7)在先      */
                                                                        /* SPIE = 0, SPI 中断被禁止     */
                                                                        /* CPHA = 0, SCK第一个时钟沿采样*/
    SPI->C1 |= SPI_C1_SPE_MASK ;                                        /* SPI使能                      */
    SPI->C1 &= ~(1 << SPI_C1_CPHA_SHIFT);
    if(bMode == Master) {                                               /* 主模式                       */
        SPI->C1 |= SPI_C1_MSTR_MASK;
    } else {                                                            /* 从模式                       */
        SPI->C1 &= ~(1 << SPI_C1_MSTR_SHIFT);
    }
    SPI->BR |= SPI_BR_SPPR(0) ;                                         /* 时钟分频                     */
}

/*********************************************************************************************************
** 函数名称: Send_Byte
** 函数功能：SPI发送一个字节数据 SPI0驱动
** 输入参数: data
** 输出参数: 无
** 返 回 值：无
*********************************************************************************************************/
INT8U Send_Byte (INT8U ucdata)
{
    INT8U ucTemp;
    while((SPI0_S & SPI_S_SPTEF_MASK) != SPI_S_SPTEF_MASK);             /* 发送前要先判断寄存器         */
    SPI0_DL = ucdata;
    
    while((SPI0_S & SPI_S_SPRF_MASK) != SPI_S_SPRF_MASK);               /* 接收数据有效                 */
    ucTemp = SPI0_DL;                                                    /* 清空接收标记寄存器           */
    ucTemp = ucTemp;
	return ucTemp;
}

/*********************************************************************************************************
** 函数名称:Get_Byte
** 函数功能:SPI接口接收一个字节数据 使用SPI0
** 输入参数:无
** 输出参数:无
*********************************************************************************************************/
INT8U Get_Byte (void)
{
    INT8U ucTemp;
    while((SPI0_S & SPI_S_SPTEF_MASK) != SPI_S_SPTEF_MASK);             /* 发送前要先判断寄存器         */
    SPI0_DL = 0xff;                                                      /* 发送空数据读取内容           */

    while((SPI0_S & SPI_S_SPRF_MASK) != SPI_S_SPRF_MASK);               /* 接收数据有效                 */
    ucTemp = SPI0_DL;
    return (INT8U)(ucTemp);                                             /* 返回接收到的数据             */
}

/*********************************************************************************************************
** Function name:           spiTX
** Descriptions:            spi初始化
** input parameters:        SPI输入基地址 查询方式发送数据
** output parameters:       none
** Returned value:          none
** Created by:              JiaoLong Liu
** Created date:            2012-12-12
**--------------------------------------------------------------------------------------------------------
** Modified by:             
** Modified date:           
*********************************************************************************************************/
void spiTX(SPI_MemMapPtr SPI,INT8U ucData)
{
    while((SPI->S & SPI_S_SPTEF_MASK) != SPI_S_SPTEF_MASK);             /* 发送前要先判断寄存器         */
    SPI->DL = ucData;
}

/*********************************************************************************************************
  END FILE 
*********************************************************************************************************/



